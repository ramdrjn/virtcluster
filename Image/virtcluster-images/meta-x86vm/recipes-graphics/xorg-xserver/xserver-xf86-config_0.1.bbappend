FILESEXTRAPATHS_prepend_x86vm := "${THISDIR}/${PN}:"
